Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: f3decf2e-3a2a-4a12-b02c-1e5bd5a2f48d, NumberOfSaves: 70], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: Project Number
Time: 2024-07-05T15:25:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.6.2.0 - Alternate UI 22.6.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 05 15:25:33 2024 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\771be0ad-a090-408d-9bac-76592f37ad6d\0c9537a9-5197-41e9-8357-465275443aeb\ifc * Database version: 5507 * Database creation date: Fri Jul 05 15:25:32 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 05 15:25:32 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 05 15:25:32 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Awaiting Approval

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding, n/a
LongName: n/a
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
In: n/a
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcFurnishingElement: DBLTD_Duten_PaperTowelDispensers_E010:Brushed Stainless Steel Folded Paper Towel Dispenser, DBLTD_Duten_PaperTowelDispensers_E010:Brushed Stainless Steel Folded Paper Towel Dispenser:465168
In: Level 0
Type - Material: DBLTD_Duten_Metal_BrushedStainlessSteel
Type - Pset_FurnitureTypeCommon - Description: Brushed Stainless Steel Folded Paper Towel Dispenser; NominalHeight: 420 mm; NominalLength: 65 mm
Type - Pset_ElementShading - Color: Brushed Stainless Steel, Polished Stainless Steel or Matte Black
Type - Pset_ManufacturerTypeInformation - ModelReference: Brushed Stainless Steel Folded Paper Towel Dispenser; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Paper Towel Dispenser; Category: Generic Models
Pset_QuantityTakeOff - Reference: Brushed Stainless Steel Folded Paper Towel Dispenser

# IfcFurnishingElement: DBLTD_Duten_PaperTowelDispensers_E010:Matte Black Folded Paper Towel Dispenser, DBLTD_Duten_PaperTowelDispensers_E010:Matte Black Folded Paper Towel Dispenser:465174
In: Level 0
Type - Material: DBLTD_Duten_Metal_MatteBlack
Type - Pset_FurnitureTypeCommon - Description: Matte Black Folded Paper Towel Dispenser; NominalHeight: 420 mm; NominalLength: 65 mm
Type - Pset_ElementShading - Color: Brushed Stainless Steel, Polished Stainless Steel or Matte Black
Type - Pset_ManufacturerTypeInformation - ModelReference: Matte Black Folded Paper Towel Dispenser; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Paper Towel Dispenser; Category: Generic Models
Pset_QuantityTakeOff - Reference: Matte Black Folded Paper Towel Dispenser

# IfcFurnishingElement: DBLTD_Duten_PaperTowelDispensers_E010:Polished Stainless Steel Folded Paper Towel Dispenser, DBLTD_Duten_PaperTowelDispensers_E010:Polished Stainless Steel Folded Paper Towel Dispenser:465180
In: Level 0
Type - Material: DBLTD_Duten_Metal_PolishedStainlessSteel
Type - Pset_FurnitureTypeCommon - Description: Polished Stainless Steel Folded Paper Towel Dispenser; NominalHeight: 420 mm; NominalLength: 65 mm
Type - Pset_ElementShading - Color: Brushed Stainless Steel, Polished Stainless Steel or Matte Black
Type - Pset_ManufacturerTypeInformation - ModelReference: Polished Stainless Steel Folded Paper Towel Dispenser; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Paper Towel Dispenser; Category: Generic Models
Pset_QuantityTakeOff - Reference: Polished Stainless Steel Folded Paper Towel Dispenser
